options:
  parameters:
    author: GNU Radio Intro Workshop
    description: USRP -> channel filter (decimate to 480 kS/s) -> WBFM receive -> soundcard
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: fm_broadcast_usrp
    output_language: python
    title: Broadcast FM Receiver (USRP)
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,1
    label: Station (Hz)
    start: '87500000.0'
    step: '100000.0'
    stop: '108000000.0'
    value: '100100000.0'
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: RF gain (dB)
    start: '0'
    step: '1'
    stop: '70'
    value: '30'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '960000'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Volume
    start: '0'
    step: '0.05'
    stop: '2'
    value: '0.5'
  states: {}
- name: audio_out
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: channel_filter
  id: low_pass_filter
  parameters:
    cutoff_freq: '100000.0'
    decim: '2'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '20000.0'
    win: window.WIN_HAMMING
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '2048'
    gui_hint: 2,0,1,2
    name: '"Spectrum"'
    type: complex
    ymin: '-120'
  states: {}
- name: usrp
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: freq
    gain0: gain
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: vol
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: waterfall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '1024'
    gui_hint: 3,0,1,2
    int_max: '-20'
    int_min: '-110'
    name: '"Waterfall"'
    type: complex
  states: {}
- name: wfm
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '10'
    quad_rate: samp_rate / 2
  states: {}

connections:
- [channel_filter, '0', wfm, '0']
- [usrp, '0', channel_filter, '0']
- [usrp, '0', spectrum, '0']
- [usrp, '0', waterfall, '0']
- [vol, '0', audio_out, '0']
- [wfm, '0', vol, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1029-g3c48f5e2
