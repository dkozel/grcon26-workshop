options:
  parameters:
    author: GNU Radio Intro Workshop
    description: File Source -> channel select + decimate -> squelch -> NBFM demod -> soundcard
    generate_options: qt_gui
    generator_class_name: PythonQtGuiGenerator
    generator_module: gnuradio.grc.workflows.python_qt_gui
    id: fm_receiver
    output_language: python
    title: NBFM Receiver (from a recording)
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: recording
  id: variable
  parameters:
    value: '"fm_band.cfile"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '240000'
  states: {}
- name: squelch
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Squelch (dB)
    start: '-100'
    step: '1'
    stop: '0'
    value: '-60'
  states: {}
- name: station
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 0,0,1,1
    label: Station
    label0: '"A: -50 kHz"'
    label1: '"B: +60 kHz"'
    label2: '"Nothing: 0 Hz"'
    num_opts: '3'
    option0: '-50000'
    option1: '60000'
    option2: '0'
    orient: Qt.QHBoxLayout
    type: real
    value: '-50000'
    widget: radio_buttons
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,2
    label: Volume
    start: '0'
    step: '0.05'
    stop: '2'
    value: '0.5'
  states: {}
- name: audio_out
  id: audio_sink
  parameters:
    samp_rate: audio_rate
  states: {}
- name: band_fall
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: 3,0,1,2
    int_max: '-20'
    int_min: '-110'
    name: '"Waterfall"'
    type: complex
  states: {}
- name: band_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 2,0,1,1
    name: '"Recorded band (240 kS/s)"'
    type: complex
    ymin: '-120'
  states: {}
- name: chan_sink
  id: qtgui_freq_sink_x
  parameters:
    bw: audio_rate
    fc: '0'
    fftsize: '2048'
    gui_hint: 2,1,1,1
    name: '"Selected channel (48 kS/s)"'
    type: complex
    ymin: '-120'
  states: {}
- name: channel_select
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: station
    decim: samp_rate // audio_rate
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0, samp_rate, 8e3, 2e3)
    type: ccc
  states: {}
- name: file_source
  id: blocks_file_source
  parameters:
    file: recording
    repeat: 'True'
    type: complex
  states: {}
- name: nbfm_rx
  id: analog_nbfm_rx
  parameters:
    audio_rate: audio_rate
    max_dev: '5000.0'
    quad_rate: audio_rate
    tau: '7.5e-05'
  states: {}
- name: squelch_blk
  id: analog_pwr_squelch_xx
  parameters:
    alpha: '0.001'
    gate: 'False'
    ramp: '0'
    threshold: squelch
    type: complex
  states: {}
- name: vol
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}

connections:
- [channel_select, '0', chan_sink, '0']
- [channel_select, '0', squelch_blk, '0']
- [file_source, '0', band_fall, '0']
- [file_source, '0', band_sink, '0']
- [file_source, '0', channel_select, '0']
- [nbfm_rx, '0', vol, '0']
- [squelch_blk, '0', nbfm_rx, '0']
- [vol, '0', audio_out, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-1029-g3c48f5e2
